# Keil uVision project Li_Zhenghai.uvprojx, settings and files
target Li_Zhenghai (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Li_Zhenghai +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\RCC;..\User\GPIO_Bit_Config;..\User\delay;..\User\GPIO_Config;..\User\NVIC;..\User\Exit;..\User\LCD12864;..\User\USART;..\User\DS3231;..\User\IIC;..\User\AT24C32;..\User\Calendar;..\User\Festival;..\User\DHT11;..\User\BasicTime
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/RCC/: rcc.c
    ../User/GPIO_Bit_Config/: GPIO_Bit_Config.c
    ../User/delay/: delay.c
    ../User/GPIO_Config/: gpio.c
    ../User/NVIC/: nvic.c
    ../User/Exit/: exit.c
    ../User/LCD12864/: lcd12864.c
    ../User/USART/: usart.c
    ../User/AT24C32/: at24c32.c
    ../User/DS3231/: ds3231.c
    ../User/IIC/: iic.c
    ../User/Calendar/: calendar.c
    ../User/Festival/: festival.c
    ../User/DHT11/: dht11.c
    ../User/BasicTime/: time.c
  group Doc
    ../Doc/: readme.txt
